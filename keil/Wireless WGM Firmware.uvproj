# Keil uVision project Wireless WGM Firmware.uvproj, settings and files
target Wireless WGM Firmware (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Wireless WGM Firmware +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c include: ..\APP\INC;..\STM32F10x_StdPeriph_Lib_V3.5.0\Libraries\CMSIS\CM3\CoreSupport;..\STM32F10x_StdPeriph_Lib_V3.5.0\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\STM32F10x_StdPeriph_Lib_V3.5.0\Libraries\STM32F10x_StdPeriph_Driver\inc;..\STM32_CPAL_Driver\inc;..\STM32_CPAL_Driver\src;..\STM32_CPAL_Driver\devices\stm32f10x;..\STM32_USB-FS-Device_Driver\inc;..\USB\inc;..\ATK-ESP8266
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group startup
    ../STM32F10x_StdPeriph_Lib_V3.5.0/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group App/source
    ../APP/SOURCE/: main.c Sys_config.c Data_Poll.c usart3.c WatchDog.c delay.c Flash.c DAC.c stm32_it.c ADC.c
    ../STM32_CPAL_Driver/src/: cpal_usercallback.c
  group App/inc
    ../APP/INC/: Includes.h stm32f10x_conf.h Sys_config.h Data_Poll.h WatchDog.h Flash.h DAC.h ADC.h delay.h usart3.h
  group CMSIS/inc
    ../STM32F10x_StdPeriph_Lib_V3.5.0/Libraries/CMSIS/CM3/CoreSupport/: core_cm3.h
    ../STM32F10x_StdPeriph_Lib_V3.5.0/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.h
  group CMSIS/source
    ../STM32F10x_StdPeriph_Lib_V3.5.0/Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../STM32F10x_StdPeriph_Lib_V3.5.0/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group StdPeriph_Driver/souce
    ../STM32F10x_StdPeriph_Lib_V3.5.0/Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group StdPeriph_Driver/inc
    ../STM32F10x_StdPeriph_Lib_V3.5.0/Libraries/STM32F10x_StdPeriph_Driver/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
  group STM32_CPAL_Driver
    ../STM32_CPAL_Driver/src/: cpal_hal.c cpal_i2c.c
    ../STM32_CPAL_Driver/devices/stm32f10x/: cpal_i2c_hal_stm32f10x.c
  group STM32_USB-FS-Device_Driver/source
    ../STM32_USB-FS-Device_Driver/src/: usb_sil.c usb_regs.c usb_mem.c usb_int.c usb_init.c usb_core.c
  group STM32_USB-FS-Device_Driver/inc
    ../STM32_USB-FS-Device_Driver/inc/: usb_core.h usb_def.h usb_init.h usb_int.h usb_lib.h usb_mem.h usb_regs.h usb_sil.h usb_type.h
  group USB/source
    ../USB/src/: hw_config.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
  group USB/inc
    ../USB/inc/: hw_config.h platform_config.h usb_conf.h usb_desc.h usb_istr.h usb_prop.h usb_pwr.h
  group ATK-ESP8266
    ../ATK-ESP8266/: common.c common.h wifiap.c wifiap.h
